<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\legato_qs_e70_xu_tm4301b.IAR.ewp</path>
    </project>
</workspace>
