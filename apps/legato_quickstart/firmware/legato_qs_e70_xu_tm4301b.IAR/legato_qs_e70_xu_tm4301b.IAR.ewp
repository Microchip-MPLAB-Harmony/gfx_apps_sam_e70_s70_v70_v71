# IAR project legato_qs_e70_xu_tm4301b.IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: ..\src; ..\src\config\lcc_rgb565_mxt_e70_IAR; ..\src\packs\ATSAME70Q21B_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lcc_rgb565_mxt_e70.out
  ILINK.IlinkIcfFile: ..\src\config\lcc_rgb565_mxt_e70_IAR\flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR
    ../src/config/lcc_rgb565_mxt_e70_IAR/: device_cache.h toolchain_specifics.h definitions.h device.h user.h configuration.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/driver/lcc
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/driver/: gfx_driver.h
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/driver/controller/lcc/: drv_gfx_lcc.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/: legato.h legato_config.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/common
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/common/: legato_color.h legato_common.h legato_error.h legato_math.h legato_pixelbuffer.h legato_rect.h legato_utils.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/core
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/core/: legato_event.h legato_input.h legato_scheme.h legato_state.h legato_stream.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/datastructure
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/datastructure/: legato_array.h legato_list.h legato_rectarray.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/font
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/font/: legato_font.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/: legato_image.h legato_palette.h legato_image_utils.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/raw
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/raw/: legato_imagedecoder_raw.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/jpeg
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/jpeg/: legato_imagedecoder_jpeg.h legato_imagedecoder_jpeg_common.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/png
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/png/: legato_imagedecoder_png.h lodepng.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/memory
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/memory/: legato_fixedheap.h legato_memory.h legato_variableheap.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/renderer
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/renderer/: legato_renderer.h legato_gpu.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/string
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/string/: legato_dynamicstring.h legato_fixedstring.h legato_string.h legato_string_renderer.h legato_stringtable.h legato_tablestring.h legato_stringutils.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/: legato_editwidget.h legato_widget.h legato_widget_skin_classic_common.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/arc
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/arc/: legato_widget_arc.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/bargraph
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/bargraph/: legato_widget_bar_graph.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/button
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/button/: legato_widget_button.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/checkbox
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/checkbox/: legato_widget_checkbox.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circle
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circle/: legato_widget_circle.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circulargauge
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circulargauge/: legato_widget_circular_gauge.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circularslider
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circularslider/: legato_widget_circular_slider.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/drawsurface
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/drawsurface/: legato_widget_drawsurface.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/gradient
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/gradient/: legato_widget_gradient.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/groupbox
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/groupbox/: legato_widget_groupbox.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/image
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/image/: legato_widget_image.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagerotate
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagerotate/: legato_widget_imagerotate.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagescale
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagescale/: legato_widget_imagescale.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagesequence
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagesequence/: legato_widget_imagesequence.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/keypad
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/keypad/: legato_widget_keypad.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/label
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/label/: legato_widget_label.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/line
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/line/: legato_widget_line.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/linegraph
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/linegraph/: legato_widget_line_graph.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/list
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/list/: legato_widget_list.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/listwheel
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/listwheel/: legato_widget_listwheel.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/piechart
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/piechart/: legato_widget_pie_chart.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/progressbar
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/progressbar/: legato_widget_progressbar.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/radialmenu
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/radialmenu/: legato_widget_radial_menu.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/radiobutton
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/radiobutton/: legato_radiobutton_group.h legato_widget_radiobutton.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/rectangle
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/rectangle/: legato_widget_rectangle.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/scrollbar
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/scrollbar/: legato_widget_scrollbar.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/slider
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/slider/: legato_widget_slider.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/textfield
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/textfield/: legato_widget_textfield.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/touchtest
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/touchtest/: legato_widget_touchtest.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/window
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/window/: legato_widget_window.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated/: le_gen_assets.h le_gen_harmony.h le_gen_init.h le_gen_scheme.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated/screen
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated/screen/: le_gen_screen_Screen0.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/clk
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/pio
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/nvic
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/nvic/: plib_nvic.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/xdmac
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/xdmac/: plib_xdmac_common.h plib_xdmac.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/efc
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/efc/: plib_efc.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/tc
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/tc/: plib_tc0.h plib_tc_common.h plib_tc2.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/smc
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/smc/: plib_smc.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/twihs
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/twihs/: plib_twihs_master.h plib_twihs0.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/driver
    ../src/config/lcc_rgb565_mxt_e70_IAR/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/driver/i2c
    ../src/config/lcc_rgb565_mxt_e70_IAR/driver/i2c/: drv_i2c.h drv_i2c_definitions.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/driver/input
    ../src/config/lcc_rgb565_mxt_e70_IAR/driver/input/: drv_maxtouch.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/system
    ../src/config/lcc_rgb565_mxt_e70_IAR/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/system/time
    ../src/config/lcc_rgb565_mxt_e70_IAR/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/lcc_rgb565_mxt_e70_IAR/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/system/input
    ../src/config/lcc_rgb565_mxt_e70_IAR/system/input/: sys_input.h sys_input_gesture.h sys_input_keyboard.h sys_input_listener.h sys_input_mouse.h sys_input_touch.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/system/int
    ../src/config/lcc_rgb565_mxt_e70_IAR/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/system/cache
    ../src/config/lcc_rgb565_mxt_e70_IAR/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/system/debug
    ../src/config/lcc_rgb565_mxt_e70_IAR/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/bsp
    ../src/config/lcc_rgb565_mxt_e70_IAR/bsp/: bsp.h
  group Harmony3/Header Files/config/lcc_rgb565_mxt_e70_IAR/osal
    ../src/config/lcc_rgb565_mxt_e70_IAR/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP
    ../src/packs/ATSAME70Q21B_DFP/: atsame70q21b.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP/component
    ../src/packs/ATSAME70Q21B_DFP/component/: acc.h aes.h afec.h chipid.h dacc.h efc.h gmac.h gpbr.h hsmci.h i2sc.h icm.h isi.h matrix.h mcan.h pio.h pmc.h pwm.h qspi.h rstc.h rswdt.h rtc.h rtt.h sdramc.h smc.h spi.h ssc.h supc.h tc.h trng.h twihs.h uart.h usart.h usbhs.h utmi.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP/pio
    ../src/packs/ATSAME70Q21B_DFP/pio/: same70q21b.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core/Include
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm7.h mpu_armv7.h cachel1_armv7.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR
    ../src/config/lcc_rgb565_mxt_e70_IAR/: initialization.c interrupts.c exceptions.c startup_iar.c tasks.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/driver/lcc
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/driver/: gfx_driver.c
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/driver/controller/lcc/: drv_gfx_lcc.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/common
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/common/: legato_color.c legato_color_blend.c legato_color_convert.c legato_color_lerp.c legato_color_value.c legato_error.c legato_math.c legato_pixelbuffer.c legato_rect.c legato_utils.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/core
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/core/: legato_event.c legato_input.c legato_scheme.c legato_state.c legato_stream.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/datastructure
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/datastructure/: legato_array.c legato_list.c legato_rectarray.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/font
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/font/: legato_font.c legato_rasterfont_liberationmono1.c legato_rasterfont_liberationmono8.c legato_rasterfont_stream.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/: legato_image.c legato_palette.c legato_image_utils.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/raw
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/raw/: legato_imagedecoder_raw.c legato_imagedecoder_raw_blend.c legato_imagedecoder_raw_convert.c legato_imagedecoder_raw_mask.c legato_imagedecoder_raw_palette_internal.c legato_imagedecoder_raw_palette_stream.c legato_imagedecoder_raw_read_internal.c legato_imagedecoder_raw_read_stream_color.c legato_imagedecoder_raw_read_stream_index.c legato_imagedecoder_raw_read_stream_rlecolor.c legato_imagedecoder_raw_read_stream_rleindex.c legato_imagedecoder_raw_rotate.c legato_imagedecoder_raw_scale.c legato_imagedecoder_raw_setup.c legato_imagedecoder_raw_write.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/jpeg
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/jpeg/: legato_imagedecoder_jpeg.c legato_imagedecoder_jpeg_common.c jidctint.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/png
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/image/png/: legato_imagedecoder_png.c lodepng.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/memory
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/memory/: legato_fixedheap.c legato_memory.c legato_variableheap.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/renderer
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/renderer/: legato_draw.c legato_draw_arc.c legato_draw_line.c legato_draw_rect.c legato_renderer.c legato_gpu.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/string
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/string/: legato_dynamicstring.c legato_fixedstring.c legato_string.c legato_string_renderer.c legato_string_renderer_stream.c legato_stringtable.c legato_tablestring.c legato_stringutils.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/: legato_editwidget.c legato_widget.c legato_widget_skin_classic.c legato_widget_skin_classic_common.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/arc
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/arc/: legato_widget_arc.c legato_widget_arc_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/bargraph
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/bargraph/: legato_widget_bar_graph.c legato_widget_bar_graph_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/button
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/button/: legato_widget_button.c legato_widget_button_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/checkbox
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/checkbox/: legato_widget_checkbox.c legato_widget_checkbox_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circle
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circle/: legato_widget_circle.c legato_widget_circle_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circulargauge
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circulargauge/: legato_widget_circular_gauge.c legato_widget_circular_gauge_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circularslider
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/circularslider/: legato_widget_circular_slider.c legato_widget_circular_slider_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/drawsurface
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/drawsurface/: legato_widget_drawsurface.c legato_widget_drawsurface_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/gradient
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/gradient/: legato_widget_gradient.c legato_widget_gradient_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/groupbox
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/groupbox/: legato_widget_groupbox.c legato_widget_groupbox_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/image
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/image/: legato_widget_image.c legato_widget_image_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagerotate
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagerotate/: legato_widget_imagerotate.c legato_widget_imagerotate_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagescale
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagescale/: legato_widget_imagescale.c legato_widget_imagescale_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagesequence
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/imagesequence/: legato_widget_imagesequence.c legato_widget_imagesequence_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/keypad
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/keypad/: legato_widget_keypad.c legato_widget_keypad_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/label
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/label/: legato_widget_label.c legato_widget_label_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/line
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/line/: legato_widget_line.c legato_widget_line_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/linegraph
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/linegraph/: legato_widget_line_graph.c legato_widget_line_graph_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/list
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/list/: legato_widget_list.c legato_widget_list_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/listwheel
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/listwheel/: legato_widget_listwheel.c legato_widget_listwheel_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/piechart
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/piechart/: legato_widget_pie_chart.c legato_widget_pie_chart_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/progressbar
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/progressbar/: legato_widget_progressbar.c legato_widget_progressbar_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/radialmenu
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/radialmenu/: legato_widget_radial_menu.c legato_widget_radial_menu_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/radiobutton
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/radiobutton/: legato_radiobutton_group.c legato_widget_radiobutton.c legato_widget_radiobutton_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/rectangle
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/rectangle/: legato_widget_rectangle.c legato_widget_rectangle_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/scrollbar
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/scrollbar/: legato_widget_scrollbar.c legato_widget_scrollbar_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/slider
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/slider/: legato_widget_slider.c legato_widget_slider_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/textfield
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/textfield/: legato_widget_textfield.c legato_widget_textfield_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/touchtest
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/touchtest/: legato_widget_touchtest.c legato_widget_touchtest_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/window
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/widget/window/: legato_widget_window.c legato_widget_window_skin_classic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated/: le_gen_globalpalette.c le_gen_harmony.c le_gen_init.c le_gen_scheme.c le_gen_stringtable.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated/font
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated/font/: le_gen_fonts.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated/image
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated/image/: le_gen_images.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated/screen
    ../src/config/lcc_rgb565_mxt_e70_IAR/gfx/legato/generated/screen/: le_gen_screen_Screen0.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/stdio
    ../src/config/lcc_rgb565_mxt_e70_IAR/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/clk
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/pio
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/nvic
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/nvic/: plib_nvic.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/xdmac
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/xdmac/: plib_xdmac.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/efc
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/efc/: plib_efc.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/tc
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/tc/: plib_tc0.c plib_tc2.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/smc
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/smc/: plib_smc.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/peripheral/twihs
    ../src/config/lcc_rgb565_mxt_e70_IAR/peripheral/twihs/: plib_twihs0.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/driver/i2c
    ../src/config/lcc_rgb565_mxt_e70_IAR/driver/i2c/src/: drv_i2c.c drv_i2c_local.h
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/driver/input
    ../src/config/lcc_rgb565_mxt_e70_IAR/driver/input/: drv_maxtouch.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/system/time
    ../src/config/lcc_rgb565_mxt_e70_IAR/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/system/input
    ../src/config/lcc_rgb565_mxt_e70_IAR/system/input/: sys_input.c sys_input_listener.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/system/int
    ../src/config/lcc_rgb565_mxt_e70_IAR/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/system/cache
    ../src/config/lcc_rgb565_mxt_e70_IAR/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/lcc_rgb565_mxt_e70_IAR/bsp
    ../src/config/lcc_rgb565_mxt_e70_IAR/bsp/: bsp.c
  group Harmony3/Linker File
    ../src/config/lcc_rgb565_mxt_e70_IAR/: flash.icf
