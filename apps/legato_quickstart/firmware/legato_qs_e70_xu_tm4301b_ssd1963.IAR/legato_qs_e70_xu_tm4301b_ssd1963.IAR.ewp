# IAR project legato_qs_e70_xu_tm4301b_ssd1963.IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: ..\src; ..\src\config\ssd1963_rgb565_mxt_e70_iar; ..\src\packs\ATSAME70Q21B_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: legato_qs_e70_xu_tm4301b_ssd1963.IAR.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar
    ../src/config/ssd1963_rgb565_mxt_e70_iar/: configuration.h definitions.h device.h device_cache.h toolchain_specifics.h user.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/bsp
    ../src/config/ssd1963_rgb565_mxt_e70_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/driver
    ../src/config/ssd1963_rgb565_mxt_e70_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/driver/i2c
    ../src/config/ssd1963_rgb565_mxt_e70_iar/driver/i2c/: drv_i2c.h drv_i2c_definitions.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/driver/input
    ../src/config/ssd1963_rgb565_mxt_e70_iar/driver/input/: drv_maxtouch.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/driver/external_controller
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/driver/controller/external_controller/: drv_gfx_external_controller.h
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/driver/: gfx_driver.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/interface
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/interface/: drv_gfx_disp_intf.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/: legato.h legato_config.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/common
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/common/: legato_color.h legato_common.h legato_error.h legato_math.h legato_pixelbuffer.h legato_rect.h legato_utils.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/core
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/core/: legato_event.h legato_input.h legato_scheme.h legato_state.h legato_stream.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/datastructure
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/datastructure/: legato_array.h legato_list.h legato_rectarray.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/font
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/font/: legato_font.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated/: le_gen_assets.h le_gen_harmony.h le_gen_init.h le_gen_scheme.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated/screen
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated/screen/: le_gen_screen_Screen0.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/: legato_image.h legato_image_utils.h legato_palette.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/jpeg
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/jpeg/: legato_imagedecoder_jpeg.h legato_imagedecoder_jpeg_common.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/png
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/png/: legato_imagedecoder_png.h lodepng.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/raw
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/raw/: legato_imagedecoder_raw.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/memory
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/memory/: legato_fixedheap.h legato_memory.h legato_variableheap.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/renderer
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/renderer/: legato_gpu.h legato_renderer.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/string
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/string/: legato_dynamicstring.h legato_fixedstring.h legato_string.h legato_string_renderer.h legato_stringtable.h legato_stringutils.h legato_tablestring.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/: legato_editwidget.h legato_widget.h legato_widget_skin_classic_common.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/arc
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/arc/: legato_widget_arc.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/bargraph
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/bargraph/: legato_widget_bar_graph.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/button
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/button/: legato_widget_button.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/checkbox
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/checkbox/: legato_widget_checkbox.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circle
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circle/: legato_widget_circle.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circulargauge
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circulargauge/: legato_widget_circular_gauge.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circularslider
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circularslider/: legato_widget_circular_slider.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/drawsurface
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/drawsurface/: legato_widget_drawsurface.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/gradient
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/gradient/: legato_widget_gradient.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/groupbox
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/groupbox/: legato_widget_groupbox.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/image
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/image/: legato_widget_image.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagerotate
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagerotate/: legato_widget_imagerotate.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagescale
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagescale/: legato_widget_imagescale.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagesequence
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagesequence/: legato_widget_imagesequence.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/keypad
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/keypad/: legato_widget_keypad.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/label
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/label/: legato_widget_label.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/line
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/line/: legato_widget_line.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/linegraph
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/linegraph/: legato_widget_line_graph.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/list
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/list/: legato_widget_list.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/listwheel
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/listwheel/: legato_widget_listwheel.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/piechart
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/piechart/: legato_widget_pie_chart.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/progressbar
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/progressbar/: legato_widget_progressbar.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/radialmenu
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/radialmenu/: legato_widget_radial_menu.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/radiobutton
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/radiobutton/: legato_radiobutton_group.h legato_widget_radiobutton.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/rectangle
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/rectangle/: legato_widget_rectangle.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/scrollbar
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/scrollbar/: legato_widget_scrollbar.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/slider
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/slider/: legato_widget_slider.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/textfield
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/textfield/: legato_widget_textfield.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/touchtest
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/touchtest/: legato_widget_touchtest.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/window
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/window/: legato_widget_window.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/osal
    ../src/config/ssd1963_rgb565_mxt_e70_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/clk
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/efc
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/efc/: plib_efc.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/mpu
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/mpu/: plib_mpu.h plib_mpu_local.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/nvic
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/nvic/: plib_nvic.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/pio
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/smc
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/smc/: plib_smc.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/tc
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/twihs
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/twihs/: plib_twihs0.h plib_twihs_master.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/system
    ../src/config/ssd1963_rgb565_mxt_e70_iar/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/system/cache
    ../src/config/ssd1963_rgb565_mxt_e70_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/system/debug
    ../src/config/ssd1963_rgb565_mxt_e70_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/system/input
    ../src/config/ssd1963_rgb565_mxt_e70_iar/system/input/: sys_input.h sys_input_gesture.h sys_input_keyboard.h sys_input_listener.h sys_input_mouse.h sys_input_touch.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/system/int
    ../src/config/ssd1963_rgb565_mxt_e70_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/ssd1963_rgb565_mxt_e70_iar/system/time
    ../src/config/ssd1963_rgb565_mxt_e70_iar/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/ssd1963_rgb565_mxt_e70_iar/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP
    ../src/packs/ATSAME70Q21B_DFP/: atsame70q21b.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP/component
    ../src/packs/ATSAME70Q21B_DFP/component/: acc.h aes.h afec.h chipid.h dacc.h efc.h gmac.h gpbr.h hsmci.h i2sc.h icm.h isi.h matrix.h mcan.h pio.h pmc.h pwm.h qspi.h rstc.h rswdt.h rtc.h rtt.h sdramc.h smc.h spi.h ssc.h supc.h tc.h trng.h twihs.h uart.h usart.h usbhs.h utmi.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAME70Q21B_DFP/pio
    ../src/packs/ATSAME70Q21B_DFP/pio/: same70q21b.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core/Include
    ../src/packs/CMSIS/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group Harmony3/Linker File
    ../src/config/ssd1963_rgb565_mxt_e70_iar/: flash.icf
  group Harmony3/Source Files
    ../src/: app.c main.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar
    ../src/config/ssd1963_rgb565_mxt_e70_iar/: exceptions.c initialization.c interrupts.c startup_iar.c tasks.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/bsp
    ../src/config/ssd1963_rgb565_mxt_e70_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/driver/i2c
    ../src/config/ssd1963_rgb565_mxt_e70_iar/driver/i2c/src/: drv_i2c.c drv_i2c_local.h
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/driver/input
    ../src/config/ssd1963_rgb565_mxt_e70_iar/driver/input/: drv_maxtouch.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/driver/external_controller
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/driver/controller/external_controller/: drv_gfx_external_controller.c
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/driver/: gfx_driver.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/interface/parallel_smc
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/interface/parallel_smc/: drv_gfx_disp_intf_parallel_smc.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/common
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/common/: legato_color.c legato_color_blend.c legato_color_convert.c legato_color_lerp.c legato_color_value.c legato_error.c legato_math.c legato_pixelbuffer.c legato_rect.c legato_utils.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/core
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/core/: legato_event.c legato_input.c legato_scheme.c legato_state.c legato_stream.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/datastructure
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/datastructure/: legato_array.c legato_list.c legato_rectarray.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/font
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/font/: legato_font.c legato_rasterfont_liberationmono1.c legato_rasterfont_liberationmono8.c legato_rasterfont_stream.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated/: le_gen_globalpalette.c le_gen_harmony.c le_gen_init.c le_gen_scheme.c le_gen_stringtable.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated/font
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated/font/: le_gen_fonts.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated/image
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated/image/: le_gen_images.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated/screen
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/generated/screen/: le_gen_screen_Screen0.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/: legato_image.c legato_image_utils.c legato_palette.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/jpeg
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/jpeg/: jidctint.c legato_imagedecoder_jpeg.c legato_imagedecoder_jpeg_common.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/png
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/png/: legato_imagedecoder_png.c lodepng.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/raw
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/image/raw/: legato_imagedecoder_raw.c legato_imagedecoder_raw_blend.c legato_imagedecoder_raw_convert.c legato_imagedecoder_raw_mask.c legato_imagedecoder_raw_palette_internal.c legato_imagedecoder_raw_palette_stream.c legato_imagedecoder_raw_read_internal.c legato_imagedecoder_raw_read_stream_color.c legato_imagedecoder_raw_read_stream_index.c legato_imagedecoder_raw_read_stream_rlecolor.c legato_imagedecoder_raw_read_stream_rleindex.c legato_imagedecoder_raw_rotate.c legato_imagedecoder_raw_scale.c legato_imagedecoder_raw_setup.c legato_imagedecoder_raw_write.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/memory
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/memory/: legato_fixedheap.c legato_memory.c legato_variableheap.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/renderer
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/renderer/: legato_draw.c legato_draw_arc.c legato_draw_line.c legato_draw_rect.c legato_gpu.c legato_renderer.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/string
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/string/: legato_dynamicstring.c legato_fixedstring.c legato_string.c legato_string_renderer.c legato_string_renderer_stream.c legato_stringtable.c legato_stringutils.c legato_tablestring.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/: legato_editwidget.c legato_widget.c legato_widget_skin_classic.c legato_widget_skin_classic_common.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/arc
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/arc/: legato_widget_arc.c legato_widget_arc_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/bargraph
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/bargraph/: legato_widget_bar_graph.c legato_widget_bar_graph_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/button
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/button/: legato_widget_button.c legato_widget_button_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/checkbox
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/checkbox/: legato_widget_checkbox.c legato_widget_checkbox_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circle
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circle/: legato_widget_circle.c legato_widget_circle_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circulargauge
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circulargauge/: legato_widget_circular_gauge.c legato_widget_circular_gauge_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circularslider
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/circularslider/: legato_widget_circular_slider.c legato_widget_circular_slider_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/drawsurface
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/drawsurface/: legato_widget_drawsurface.c legato_widget_drawsurface_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/gradient
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/gradient/: legato_widget_gradient.c legato_widget_gradient_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/groupbox
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/groupbox/: legato_widget_groupbox.c legato_widget_groupbox_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/image
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/image/: legato_widget_image.c legato_widget_image_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagerotate
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagerotate/: legato_widget_imagerotate.c legato_widget_imagerotate_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagescale
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagescale/: legato_widget_imagescale.c legato_widget_imagescale_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagesequence
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/imagesequence/: legato_widget_imagesequence.c legato_widget_imagesequence_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/keypad
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/keypad/: legato_widget_keypad.c legato_widget_keypad_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/label
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/label/: legato_widget_label.c legato_widget_label_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/line
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/line/: legato_widget_line.c legato_widget_line_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/linegraph
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/linegraph/: legato_widget_line_graph.c legato_widget_line_graph_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/list
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/list/: legato_widget_list.c legato_widget_list_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/listwheel
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/listwheel/: legato_widget_listwheel.c legato_widget_listwheel_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/piechart
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/piechart/: legato_widget_pie_chart.c legato_widget_pie_chart_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/progressbar
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/progressbar/: legato_widget_progressbar.c legato_widget_progressbar_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/radialmenu
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/radialmenu/: legato_widget_radial_menu.c legato_widget_radial_menu_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/radiobutton
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/radiobutton/: legato_radiobutton_group.c legato_widget_radiobutton.c legato_widget_radiobutton_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/rectangle
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/rectangle/: legato_widget_rectangle.c legato_widget_rectangle_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/scrollbar
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/scrollbar/: legato_widget_scrollbar.c legato_widget_scrollbar_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/slider
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/slider/: legato_widget_slider.c legato_widget_slider_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/textfield
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/textfield/: legato_widget_textfield.c legato_widget_textfield_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/touchtest
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/touchtest/: legato_widget_touchtest.c legato_widget_touchtest_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/window
    ../src/config/ssd1963_rgb565_mxt_e70_iar/gfx/legato/widget/window/: legato_widget_window.c legato_widget_window_skin_classic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/clk
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/efc
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/efc/: plib_efc.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/mpu
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/mpu/: plib_mpu.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/nvic
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/nvic/: plib_nvic.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/pio
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/smc
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/smc/: plib_smc.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/tc
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/peripheral/twihs
    ../src/config/ssd1963_rgb565_mxt_e70_iar/peripheral/twihs/: plib_twihs0.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/stdio
    ../src/config/ssd1963_rgb565_mxt_e70_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/system/cache
    ../src/config/ssd1963_rgb565_mxt_e70_iar/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/system/input
    ../src/config/ssd1963_rgb565_mxt_e70_iar/system/input/: sys_input.c sys_input_listener.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/system/int
    ../src/config/ssd1963_rgb565_mxt_e70_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/ssd1963_rgb565_mxt_e70_iar/system/time
    ../src/config/ssd1963_rgb565_mxt_e70_iar/system/time/src/: sys_time.c
